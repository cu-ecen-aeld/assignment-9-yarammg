## base_external/package/ldd/Config.in
```kconfig
config BR2_PACKAGE_LDD
	bool "ldd"
	help
	  Linux Device Drivers 3 examples updated to work with recent kernels.
```
